# Keil uVision project stm32f103_project.uvprojx, settings and files
target stm32f10x_project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103_project +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\app;.\bsp;.\core;.\drivers;.\module_lib;.\Standard_Periphery\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab)
  group user_app
    ./app/: main.c
  group bsp
    ./bsp/: led.c
  group core
    ./core/: system_stm32f10x.c startup_stm32f10x_md.s
  group drivers
    ./drivers/: usart.c
  group std_periphery
    ./Standard_Periphery/src/: stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c misc.c
software components: RTOS:device drivers 3.1.1, RTOS:kernel 3.1.1, RTOS:shell 3.1.1
